# Keil uVision project STM32F103VET6.uvprojx, settings and files
target LiteOS_VET6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103VET6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\kernel\include;..\..\kernel\base\include;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\link\keil;..\..\kernel\cpu\arm\cortex-m3;..\..\example\include;..\..\platform\STM32F103VET6;..\..\platform\STM32F103VET6\Bsp;..\..\platform\STM32F103VET6\User;..\..\platform\STM32F103VET6\Libraries\CMSIS\CM3\CoreSupport;..\..\platform\STM32F103VET6\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\platform\STM32F103VET6\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\kernel\cpu\arm\cortex-m3;..\..\user;..\..\utility\inlcude;..\..\main;..\..\utility\led;..\..\utility\gpio;..\..\utility\drivers;..\..\main\system;..\..\ztoy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\platform\STM32F103VET6\STM32F103VET6-LiteOS.sct
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group config
    ../../kernel/config/: los_config.c
  group cpu-m3
    ../../kernel/cpu/arm/cortex-m3/: los_dispatch_keil.s los_hw.c los_hwi.c los_hw_tick.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
    ../../platform/STM32F103VET6/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group platform-STM32F103VET6
    ../../platform/STM32F103VET6/Bsp/: bsp_led.c bsp_usart.c los_bsp_adapter.c los_bsp_flash.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group startup
    ../../platform/STM32F103VET6/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group user
    ../../platform/STM32F103VET6/User/: system_stm32f10x.c stm32f10x_it.c
  group library
    ../../platform/STM32F103VET6/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group utility
    ../../utility/misc/: console.c debug.c
    ../../utility/led/: led_driver.c led_driverCmd.c
    ../../utility/gpio/: gpio.c gpio_driverCmd.c motor.c interface.c
    ../../utility/drivers/: l293d.c MotorCtrl.c motorCtrl_Cmd.c
  group main
    ../../main/: main_task.c
    ../../platform/STM32F103VET6/: main.c
    ../../main/system/: ToyCarManager.c ToyCarOffState.c ToyCarFactory.c ToyCarState.c ToyCarAvoidenceState.c
  group ztoy
    ../../ztoy/: sti_Gpio.c sti_Timer.c sti_Interrupt.c
